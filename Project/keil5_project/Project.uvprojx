# Keil uVision project Project.uvprojx, settings and files
target GD32E10X (6220000::V6.22::ARMCLANG)
  device: GD32E103C8 GigaDevice
  pack: GigaDevice.GD32E10x_DFP.1.2.1
  cpu: IRAM(0x20000000,0x05000) IROM(0x08000000,0x010000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_STDPERIPH_DRIVER,GD32E10X,GD32E103V_EVAL, __FPU_USED=1, __FPU_PRESENT=1
  c include: ..\;..\..\Firmware\CMSIS;..\..\Firmware\CMSIS\GD\GD32E10x\Include;..\..\Firmware\GD32E10x_standard_peripheral\Include;..\..\Utilities;..\user\OLED;..\..\Firmware\GD32E10x_usbfs_library\driver\Include;..\..\Firmware\GD32E10x_usbfs_library\device\core\Include;..\..\Firmware\GD32E10x_usbfs_library\device\class\cdc\Include;..\..\Firmware\GD32E10x_usbfs_library\ustd\class\cdc;..\..\Firmware\GD32E10x_usbfs_library\ustd\common;..\user\SYS
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application
    ../: main.c gd32e10x_it.c systick.c gd32e10x_hw.c
  group CMSIS
    ../../Firmware/CMSIS/GD/GD32E10x/Source/: system_gd32e10x.c
  group Peripherals
    ../../Firmware/GD32E10x_standard_peripheral/Source/: gd32e10x_adc.c gd32e10x_bkp.c gd32e10x_crc.c gd32e10x_ctc.c gd32e10x_dac.c gd32e10x_dbg.c gd32e10x_dma.c gd32e10x_exmc.c gd32e10x_exti.c gd32e10x_fmc.c gd32e10x_fwdgt.c gd32e10x_gpio.c gd32e10x_i2c.c gd32e10x_misc.c gd32e10x_pmu.c gd32e10x_rcu.c gd32e10x_rtc.c gd32e10x_spi.c gd32e10x_timer.c gd32e10x_usart.c gd32e10x_wwdgt.c
  group Startup
    ../../Firmware/CMSIS/GD/GD32E10x/Source/ARM/: startup_gd32e10x.s
  group Utilities
    ../../Utilities/: gd32e10x_eval.c
  group Doc
    ../: readme.txt
  group USER
    ../user/OLED/: jkd_oled.c oledfont.c
    ../user/SYS/: adc_dc_sample.c CtlLoop.c function.c protection.c sys_bsp.h mypid.c
  group USB_Device
    ../../Firmware/GD32E10x_usbfs_library/device/core/Source/: usbd_core.c usbd_enum.c usbd_transc.c
  group USB_Divers
    ../../Firmware/GD32E10x_usbfs_library/driver/Source/: drv_usb_core.c drv_usbd_int.c drv_usb_dev.c
  group USB_Class
    ../../Firmware/GD32E10x_usbfs_library/device/class/cdc/Source/: cdc_acm_core.c
software components: CMSIS:CORE 6.1.0
